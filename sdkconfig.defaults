## sdkconfig.defaults
```kconfig
# Enable IPV6 stateless address autoconfiguration (SLAAC)
CONFIG_LWIP_IPV6_AUTOCONFIG=y
# Enable websocket support in httpd server
CONFIG_HTTPD_WS_SUPPORT=y
```
